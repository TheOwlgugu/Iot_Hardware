# Keil uVision project project.uvprojx, settings and files
target Target 1 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: project
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER
  c include: .\Start;.\User;.\Library;.\System;.\Hardware;.\Mode;.\Test
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Start
    ./Start/: core_cm3.c core_cm3.h startup_stm32f10x_cl.s stm32f10x.h system_stm32f10x.c system_stm32f10x.h
  group Library
    ./Library/: misc.c misc.h stm32f10x_adc.c stm32f10x_adc.h stm32f10x_bkp.c stm32f10x_bkp.h stm32f10x_can.c stm32f10x_can.h stm32f10x_cec.c stm32f10x_cec.h stm32f10x_crc.c stm32f10x_crc.h stm32f10x_dac.c stm32f10x_dac.h stm32f10x_dbgmcu.c stm32f10x_dbgmcu.h stm32f10x_dma.c stm32f10x_dma.h stm32f10x_exti.c stm32f10x_exti.h stm32f10x_flash.c stm32f10x_flash.h stm32f10x_fsmc.c stm32f10x_fsmc.h stm32f10x_gpio.c stm32f10x_gpio.h stm32f10x_i2c.c stm32f10x_i2c.h stm32f10x_iwdg.c stm32f10x_iwdg.h stm32f10x_pwr.c stm32f10x_pwr.h stm32f10x_rcc.c stm32f10x_rcc.h stm32f10x_rtc.c stm32f10x_rtc.h stm32f10x_sdio.c stm32f10x_sdio.h stm32f10x_spi.c stm32f10x_spi.h stm32f10x_tim.c stm32f10x_tim.h stm32f10x_usart.c stm32f10x_usart.h stm32f10x_wwdg.c stm32f10x_wwdg.h
  group Hardware
    ./Hardware/: Key.c Key.h SoftI2C.c SoftI2C.h OLED.c OLED.h OLED_Font.h OneWire.c OneWire.h Serial2.c Serial2.h Serial.c Serial.h ESP8266_Driver.c ESP8266_Driver.h MySPI.c MySPI.h W25Q64.c W25Q64.h W25Q64_Ins.h Config.h Config.c Serial3.h Serial3.c Watchdog.h Watchdog.c Ra08_Driver.h Ra08_Driver.c Power.c Power.h LowPower.c LowPower.h SystemData.c SystemData.h
  group System
    ./System/: Delay.c Delay.h Millis.c Millis.h Board.c Board.h
  group Test
    ./Test/: TestMode.c TestMode.h NetTest.c NetTest.h WiFiTest.c WiFiTest.h LoRaTest.c LoRaTest.h Bridge.c Bridge.h
  group User
    ./User/: main.c stm32f10x_conf.h stm32f10x_it.c stm32f10x_it.h StartLink.c StartLink.h
  group Mode
    ./Mode/: Packet.c Packet.h Network.h Network.c WiFiMode.c WiFiMode.h LoRaMode.c LoRaMode.h NodeMode.c NodeMode.h DataMode.c DataMode.h BuzzerMode.c BuzzerMode.h Downlink.c Downlink.h Display.c Display.h Ds18b20Mode.c Ds18b20Mode.h Aht21Mode.c Aht21Mode.h Pms7003Mode.c Pms7003Mode.h Usart2Down.c Usart2Down.h Scd40Mode.c Scd40Mode.h LightMode.c LightMode.h
